# Keil uVision project balanced_infantry.uvprojx, settings and files
target HUST_infantry (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: balanced_infantry
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx, ARM_MATH_CM4, __FPU_PRESENT=1, __FPU_USED =1, __CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c include: ..\FreeRTOS\include;..\FreeRTOS\port\RVDS\ARM_CM4F;..\Library\CMSIS;..\Library\CMSIS\FastMath;..\Library\SEGGER_RTT_V784\Config;..\Library\SEGGER_RTT_V784\RTT;..\Library\inc;..\User\inc\app;..\User\inc\config;..\User\inc\FATFS;..\User\inc\motor;..\User\inc\os;..\User\inc\peripheral;..\User\inc\sys;..\User\inc\tools;..\Algorithm\inc;..\Mylib\inc;..\Task\inc;..\User\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User/app
    ../User/src/sys/: stm32f4xx_it.c system_stm32f4xx.c startup_stm32f40_41xxx.s
    ../User/src/app/: main.c ChasisController.c GimbalReceive.c GimbalSend.c HeatControl.c ins.c mecanum.c PowerLimit.c
  group Library
    ../Library/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_dac.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c stm32f4xx_dbgmcu.c stm32f4xx_spi.c
    ../Library/SEGGER_RTT_V784/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
    ../Library/CMSIS/FastMath/: arm_atan2_f32.c
    $TC_ROOT$/../../../../Data/Robomaster/RM_test/Chassis/Library/CMSIS/: arm_cortexM4lf_math.lib
  group Mylib
    ../Mylib/src/: bluetooth.c bsp_referee.c bsp_superpower.c can_receive.c can_send.c can1.c can2.c counter.c dji_remote.c i2c.c iwdg.c led.c os_tick.c pc_uart.c VOFA.c wifi.c
  group Algorithm
    ../Algorithm/src/: accel.c algorithmOfCRC.c crc32.c kalman_filter.c my_filter.c Observer.c pid.c QuaternionEKF.c RLS_Identification.c SignalGenerator.c SystemIdentification.c TD.c user_lib.c wheel_ins.c
  group Task
    ../Task/src/: ActionTask.c BlueToothTask.c ChasisControlTask.c ChasisEstimateTask.c CPU_Task.c GimbalTask.c iwdgTask.c Offline_Task.c PowerControlTask.c RefereeTask.c SDCardTask.c Start_Task.c Test_Task.c
  group FreeRTOS/src
    ../FreeRTOS/src/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS/port
    ../FreeRTOS/port/MemMang/: heap_4.c
    ../FreeRTOS/port/RVDS/ARM_CM4F/: port.c
  group SD
    ../Mylib/src/: bsp_spi_sdcard.c
    ../User/inc/FATFS/: diskio.c ff.c
  group User/motor
    ../User/src/motor/: GM6020.c M2006.c M3508.c
  group User/peripheral
    ../User/src/peripheral/: icm20602.c ina260.c Referee.c remote_control.c SuperPower.c
  group Uset/tools
    ../User/src/tools/: debug.c tools.c ZeroCheck.c
  group config
    ../User/inc/config/: robot_config.c
